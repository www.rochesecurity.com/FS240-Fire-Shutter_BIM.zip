Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-03-03T08:16:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Mar 03 08:16:20 2022* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{F8044980-D462-4BE3-B3B5-8899782FF0A3}\ifc* Database version: 5507* Database creation date: Thu Mar 03 08:16:19 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Mar 03 08:16:19 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Mar 03 08:16:19 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDoor: 2500x2000mm, NBS_RocheSystemsLtd_FireResRllrShttrs_FS240FireShutter:2500x2000mm:371783
In: Level 0
Type - OperationType: ROLLINGUP; ConstructionType: STEEL; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_84_30 (Uniclass2015); Material: NBS_RocheSystems_Galvanised, NBS_RocheSystems_Curtain76mm_Galvanised
Type - NBS_RocheSystemsLtd_FireResRllrShttrs_FS240FireShutter:2500x2000mm:371783 - PanelOperation: ROLLINGUP
Type - BOS_General - Author: NBS; BIMObjectName: NBS_RochéSystemsLtd_FireResistingRollerShutters_FS240FireShutter; ManufacturerName: Roché Systems Ltd; ManufacturerURL: www.rochesystems.com; NBSCertification: www.nationalbimlibrary.com/cert/5ga0m0mf; ProductInformation: n/a; Uniclass2015Title: Fire-resisting roller shutters; Uniclass2015Code: Pr_30_59_84_30; Uniclass2015Version: Products v1.22; Version: 1
Type - NBS_Data - Accessibility: n/a; Accessories: None, Crank handle, Manual override facility, Interface panel; AcousticPerformance: n/a; AirPermeability: n/a; ApplicationConformity: n/a; Arrangement: Vertical, external face fix, Vertical, internal face fix, Vertical, reveal fix; BulletResistance: n/a; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; Execution: n/a; ExplosionResistanceBlastDuration: n/a; ExplosionResistanceOverpressureMaximum: n/a; ExplosionResistancePressureMode: n/a; ExplosionResistanceReboundPressureMaximum: n/a; Format: n/a; FrameAndGuidesMaterialColour: n/a; FrameAndGuidesMaterialFilmThicknessMinimum: n/a; FrameAndGuidesMaterialFinish: Galvanized, Polyester powder coated, BS, Polyester powder coated, RAL; FrameAndGuidesMaterialFrameAccessories: n/a; FrameAndGuidesMaterialInstallationFasteners: n/a; FrameAndGuidesMaterialPerimeterSealsOrInserts: n/a; GuideChannelsDepth: 65 mm, 75 mm, 100 mm; IntruderResistanceRequirement: n/a; OpeningSizes: 12 000 x 4750 mm; Operation: ROLLINGUP; PerformanceFirePerformanceFireResistance: Four hours; PerformanceFirePerformanceSmokeLeakage: n/a; Recyclability: n/a; RecycledContent: n/a; ResistanceToWindLoad: n/a; ShutterCurtainFinishAndColour: Galvanized, Plastisol coated, BS, Plastisol coated, RAL, Polyester powder coated, BS, Polyester powder coated, RAL; ShutterCurtainLathMaterial: Single skin curved steel, 76 mm in height. 0.7, 0.9 or 1.2 mm wall thickness, dependent on overall width. Bottom slat: T-shaped st﻿eel; ShutterCurtainProfile: n/a; Standard: To BS EN 16034:2014 and BS EN 1634-1; ThermalResistance: n/a; Watertightness: n/a; Weight: 9–16 kg/m²
Type - IFC - IfcExportAs: IfcDoor; IfcExportType: DOOR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_84_30:Fire-resisting roller shutters; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Exova Warringtonfire approved single skin steel roller shutter; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: info@rochesystems.com; Material: n/a; ModelNumber: n/a; ModelReference: FS240 Fire Shutter; Name: FireResistingRollerShutters_FS240FireShutter_RochéSystemsLtd; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 2305 mm; OverallWidth: 2800 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
